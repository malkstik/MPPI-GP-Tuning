Commit message: Crashing on pc, try laptop

File: assets/objects/obstacle/obstacle.urdf (robot description, URDF)
Before this commit: robot obstacle.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.025 .04 .1; visual box size=.025 0.04 .1
